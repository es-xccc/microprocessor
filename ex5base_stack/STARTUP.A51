ORG 0000h
JMP LOOP ;jump into loop
ORG 0030h
LOOP:
		MOV SP, #32H
		MOV A, #0xfe
		MOV P2, A
		SETB P1.0
		MOV R0, #8d
		JNB P1.0, MARQUEE
		JMP LOOP
MARQUEE:
		PUSH 00h
		MOV R0, #250d
		CALL DELAY1
		POP 00h
		RL A
		MOV P2, A
		DJNZ R0, MARQUEE
		JMP LOOP
DELAY1:
		PUSH 00h
		MOV R0, #250d
		CALL DELAY2
		POP 00h
		DJNZ R0, DELAY
		RET
DELAY2:
		DJNZ R0, DELAY2
		RET
		END